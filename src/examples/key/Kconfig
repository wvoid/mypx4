## src/examples/key/Kconfig
```kconfig
menuconfig EXAMPLES_KEY
	bool "key"
	default n
	---help---
		Enable support for key
```
